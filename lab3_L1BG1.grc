options:
  parameters:
    author: Edgar_Andres
    category: Modulos_L1BG1
    copyright: Efren Acevedo
    generate_options: hb_qt_gui
    id: CalculoPotenciaCom1
    output_language: python
    title: CalculoPotenciaCom1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ModulosEfren_SumaVector_0
  id: ModulosEfren_SumaVector
  parameters:
    l_vect: l_vect
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: l_vect
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*135115.625)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: l_vect
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: l_vect
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: l_vect
  id: parameter
  parameters:
    label: longitud fft
    type: intx
    value: '1024'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potencia
    name: '"Potencia logaritmica [dBm]"'
    type: float
    unit1: '[dBm]'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potencia
    name: '"Potencia lineal [W]"'
    type: float
    unit1: '[W]'
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potencia
    name: '"Potencia Logaritmica [dBW]"'
    type: float
    unit1: '[dBW]'
  states: {}

connections:
- [ModulosEfren_SumaVector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', ModulosEfren_SumaVector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_1, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
